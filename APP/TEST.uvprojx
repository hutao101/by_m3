# Keil uVision project TEST.uvprojx, settings and files
target TEST (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: TEST +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10x_FWLib\inc;..\CORE;..\APP;..\USMART;..\SAMPLE\USART\inc;..\SAMPLE\USART\sample_usart;..\SAMPLE\CAN\inc;..\SAMPLE\CAN\drive;..\SAMPLE\DBGMCU\inc;..\SAMPLE\FLASH\inc;..\SAMPLE\USB;..\SYSTEM\src;..\SYSTEM\malloc
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group APP
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SAMPLE
    ../SAMPLE/USART/testcase/: sample_uart_t1.c
    ../SAMPLE/USART/sample_usart/: sample_uart.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/src/: unity.c
    ../SYSTEM/malloc/: malloc.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_cl.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_usart.c
